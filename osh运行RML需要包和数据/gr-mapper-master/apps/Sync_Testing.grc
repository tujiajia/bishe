<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sync_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Rotation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Rotation</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>pi/100</value></param>
<param><key>stop</key><value>2*pi</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>40</value></param>
<param><key>label</key><value>SNR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>20</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pream</value></param>
<param><key>value</key><value>(mapper.preamble_generator(pream_len,511,1033)).get_preamble()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pream_len</value></param>
<param><key>value</key><value>84</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>Offset</value></param>
<param><key>noise_voltage</key><value>10**(-SNR/20.0)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>exp( (0 + 1j*Rotation) )</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>1.5*pi/100</value></param>
<param><key>order</key><value>8</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from cmath import exp, pi; from random import randint;</value></param>
</block>
<block>
<key>mapper_demapper</key>
<param><key>id</key><value>mapper_demapper_0</value></param>
<param><key>modtype</key><value>mapper.PSK8</value></param>
<param><key>symbol_values</key><value>[0,1,2,3,4,5,6,7]</value></param>
</block>
<block>
<key>mapper_mapper</key>
<param><key>id</key><value>mapper_mapper_0</value></param>
<param><key>modtype</key><value>mapper.PSK8</value></param>
<param><key>symbol_values</key><value>[0,1,2,3,4,5,6,7]</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>100000</value></param>
</block>
<block>
<key>mapper_preamble_insert_bb</key>
<param><key>id</key><value>mapper_preamble_insert_bb_0</value></param>
<param><key>preamble</key><value>pream</value></param>
<param><key>width</key><value>pream_len*10</value></param>
</block>
<block>
<key>mapper_preamble_sync_cc</key>
<param><key>id</key><value>mapper_preamble_sync_cc_0</value></param>
<param><key>gtas</key><value>.97</value></param>
<param><key>gtls</key><value>.9</value></param>
<param><key>modtype</key><value>mapper.PSK8</value></param>
<param><key>preamble</key><value>pream</value></param>
<param><key>symbol_map</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>width</key><value>pream_len*10</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>840-84</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>840-84</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>840-84</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>mapper_preamble_insert_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>mapper_preamble_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_0</source_block_id><sink_block_id>blocks_vector_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_mapper_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_insert_bb_0</source_block_id><sink_block_id>mapper_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_sync_cc_0</source_block_id><sink_block_id>mapper_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_sync_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
